File: LDO/HT7533-1/HT7533-1.kicad_pcb (KiCad board)
At the start: 2 copper layers, 5 parts, among them U1 HT75xx-1-SOT89

Commit message: update files to kicad 6
Other:
- net class Default removed
