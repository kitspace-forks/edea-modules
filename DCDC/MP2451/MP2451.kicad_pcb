File: DCDC/MP2451/MP2451.kicad_pcb (KiCad board)
At the start: 2 copper layers, 9 parts, among them U1 MP2451

Commit message: update files to kicad 6
Other:
- net class Default removed
